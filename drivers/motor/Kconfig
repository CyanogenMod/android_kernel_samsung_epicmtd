## drivers/motor/Kconfig
```kconfig
#
# Immersion TouchSense Player driver configuration
#
menuconfig VIBETONZ
	tristate "VibeTonz"
	default m
	help
	  Say Y to enable Vibetonz support.
```
